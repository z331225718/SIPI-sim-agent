[IBIS Ver]   5.0
[File Name]   as4c512m16md4v-053bin.ibs
[File Rev]   1.0
[Date]   2023-05-02
[Source]   Alliance Memory Inc.
   The Following information corresponds to the
   8Gb LPDDR4X 1CH X16 Die.
[Notes]   Rev 1.0 : 02, May. 2023
   File checked by IBISCHK7 V7.1.1.
   While ibischk may report monotonicity warnings,
   the non-monotonic points are not in the "active region"
   of the device.
[Disclaimer] This IBIS model provided "as is" with no warranty and AM
                is not responsible for any problems this model may cause to
                the customers. Customers may only modify the IBIS model to
                fit their particular application.
[Copyright]   Copyright 2023. Alliance Memory Inc. All rights reserved.
[Component]   AS4C512M16MD4V-053BIN
[Manufacturer]  Alliance Memory Inc.
[Package]   |200-BALL FBGA (10.0 X 15.0 X 1.0)
|   typ   min   max
R_pkg   1.233Ohm   0.863Ohm   3.560Ohm
L_pkg   1.746nH   1.301nH   4.025nH
C_pkg   1.058pF   0.788pF   3.870pF
[Pin] signal_name model_name R_pin L_pin C_pin
A1   DNU   NC
A2   DNU   NC
A3   VSS   GND
A4   VDD2   POWER
A5   ZQ_a   NC
A8   NC   NC
A9   VDD2   POWER
A10   VSS   GND
A11   DNU   NC
A12   DNU   NC
B1   DNU   NC
B2   DQ0_a   DQ_PIN   0.951   1.431nH   0.830pF
B3   VDDQ   POWER
B4   DQ7_a   DQ_PIN   0.942   1.390nH   0.847pF
B5   VDDQ   POWER
B8   VDDQ   POWER
B9   DQ15_a   DQ_PIN   0.959   1.410nH   0.812pF
B10   VDDQ   POWER
B11   DQ8_a   DQ_PIN   0.891   1.393nH   0.832pF
B12   DNU   NC
C1   VSS   GND
C2   DQ1_a   DQ_PIN   0.900   1.398nH   0.854pF
C3   DMI0_a   DQ_PIN   0.933   1.484nH   0.820pF
C4   DQ6_a   DQ_PIN   0.897   1.365nH   0.848pF
C5   VSS   GND
C8   VSS   GND
C9   DQ14_a   DQ_PIN   0.885   1.346nH   0.837pF
C10   DMI1_a   DQ_PIN   0.920   1.431nH   0.862pF
C11   DQ9_a   DQ_PIN   0.890   1.375nH   0.788pF
C12   VSS   GND
D1   VDDQ   POWER
D2   VSS   GND
D3   DQS0_t_a   DQ_PIN   0.936   1.416nH   0.833pF
D4   VSS   GND
D5   VDDQ   POWER
D8   VDDQ   POWER
D9   VSS   GND
D10   DQS1_t_a   DQ_PIN   0.925   1.416nH   0.826pF
D11   VSS   GND
D12   VDDQ   POWER
E1   VSS   GND
E2   DQ2_a   DQ_PIN   0.918   1.370nH   0.796pF
E3   DQS0_c_a   DQ_PIN   0.979   1.469nH   0.836pF
E4   DQ5_a   DQ_PIN   0.870   1.322nH   0.862pF
E5   VSS   GND
E8   VSS   GND
E9   DQ13_a   DQ_PIN   0.863   1.301nH   0.840pF
E10   DQS1_c_a   DQ_PIN   0.968   1.461nH   0.830pF
E11   DQ10_a   DQ_PIN   0.912   1.370nH   0.788pF
E12   VSS   GND
F1   VDD1   POWER
F2   DQ3_a   DQ_PIN   0.971   1.438nH   0.844pF
F3   VDDQ   POWER
F4   DQ4_a   DQ_PIN   0.906   1.365nH   0.807pF
F5   VDD2   POWER
F8   VDD2   POWER
F9   DQ12_a   DQ_PIN   0.903   1.357nH   0.835pF
F10   VDDQ   POWER
F11   DQ11_a   DQ_PIN   0.949   1.414nH   0.823pF
F12   VDD1   POWER
G1   VSS   GND
G2   ODT_CA_a   CKE_PIN   1.637   2.217nH   1.206pF
G3   VSS   GND
G4   VDD1   POWER
G5   VSS   GND
G8   VSS   GND
G9   VDD1   POWER
G10   VSS   GND
G11   NC   NC
G12   VSS   GND
H1   VDD2   POWER
H2   CA0_a   CA_PIN   1.674   2.276nH   1.293pF
H3   NC   NC
H4   CS_a   CS_PIN   1.645   2.272nH   1.230pF
H5   VDD2   POWER
H8   VDD2   POWER
H9   CA2_a   CA_PIN   1.654   2.196nH   1.280pF
H10   CA3_a   CA_PIN   1.640   2.235nH   1.263pF
H11   CA4_a   CA_PIN   1.586   2.201nH   1.294pF
H12   VDD2   POWER
J1   VSS   GND
J2   CA1_a   CA_PIN   1.648   2.218nH   1.270pF
J3   VSS   GND
J4   CKE_a   CKE_PIN   1.502   2.152nH   1.209pF
J5   NC   NC
J8   CK_t_a   CLK_PIN   1.696   2.290nH   1.249pF
J9   CK_c_a   CLK_PIN   1.711   2.236nH   1.271pF
J10   VSS   GND
J11   CA5_a   CA_PIN   1.717   2.321nH   1.296pF
J12   VSS   GND
K1   VDD2   POWER
K2   VSS   GND
K3   VDD2   POWER
K4   VSS   GND
K5   NC   NC
K8   NC   NC
K9   VSS   GND
K10   VDD2   POWER
K11   VSS   GND
K12   VDD2   POWER
N1   VDD2   POWER
N2   VSS   GND
N3   VDD2   POWER
N4   VSS   GND
N5   NC   NC
N8   NC   NC
N9   VSS   GND
N10   VDD2   POWER
N11   VSS   GND
N12   VDD2   POWER
P1   VSS   GND
P2   NC   NC
P3   VSS   GND
P4   NC   NC
P5   NC   NC
P8   NC   NC
P9   NC   NC
P10   VSS   GND
P11   NC   NC
P12   VSS   GND
R1   VDD2   POWER
R2   NC   NC
R3   NC   NC
R4   NC   NC
R5   VDD2   POWER
R8   VDD2   POWER
R9   NC   NC
R10   NC   NC
R11   NC   NC
R12   VDD2   POWER
T1   VSS   GND
T2   NC   NC
T3   VSS   GND
T4   VDD1   POWER
T5   VSS   GND
T8   VSS   GND
T9   VDD1   POWER
T10   VSS   GND
T11   RESET_n   CKE_PIN
T12   VSS   GND
U1   VDD1   POWER
U2   NC   NC
U3   VDDQ   POWER
U4   NC   NC
U5   VDD2   POWER
U8   VDD2   POWER
U9   NC   NC
U10   VDDQ   POWER
U11   NC   NC
U12   VDD1   POWER
V1   VSS   GND
V2   NC   NC
V3   NC   NC
V4   NC   NC
V5   VSS   GND
V8   VSS   GND
V9   NC   NC
V10   NC   NC
V11   NC   NC
V12   VSS   GND
W1   VDDQ   POWER
W2   VSS   GND
W3   NC   NC
W4   VSS   GND
W5   VDDQ   POWER
W8   VDDQ   POWER
W9   VSS   GND
W10   NC   NC
W11   VSS   GND
W12   VDDQ   POWER
Y1   VSS   GND
Y2   NC   NC
Y3   NC   NC
Y4   NC   NC
Y5   VSS   GND
Y8   VSS   GND
Y9   NC   NC
Y10   NC   NC
Y11   NC   NC
Y12   VSS   GND
AA1   DNU   NC
AA2   NC   NC
AA3   VDDQ   POWER
AA4   NC   NC
AA5   VDDQ   POWER
AA8   VDDQ   POWER
AA9   NC   NC
AA10   VDDQ   POWER
AA11   NC   NC
AA12   DNU   NC
AB1   DNU   NC
AB2   DNU   NC
AB3   VSS   GND
AB4   VDD2   POWER
AB5   VSS   GND
AB8   VSS   GND
AB9   VDD2   POWER
AB10   VSS   GND
AB11   DNU   NC
AB12   DNU   NC
|*****************************  MODEL SELECTOR *********************************
[Model Selector]   CA_PIN
CA_ODT_40OHM   "CA_ODT_40OHM"
CA_ODT_48OHM   "CA_ODT_48OHM"
CA_ODT_60OHM   "CA_ODT_60OHM"
CA_ODT_80OHM   "CA_ODT_80OHM"
CA_ODT_120OHM   "CA_ODT_120OHM"
CA_ODT_240OHM   "CA_ODT_240OHM"
CA_UNTERM   "CA_UNTERM"
CA_ODT_60OHM_06VDDQ   "CA_ODT_60OHM, FOR 06VDDQ MODEL"
CA_ODT_120OHM_06VDDQ   "CA_ODT_120OHM, FOR 06VDDQ MODEL"
[Model Selector]   CLK_PIN
CK_ODT_40OHM   "CK_ODT_40OHM"
CK_ODT_48OHM   "CK_ODT_48OHM"
CK_ODT_60OHM   "CK_ODT_60OHM"
CK_ODT_80OHM   "CK_ODT_80OHM"
CK_ODT_120OHM   "CK_ODT_120OHM"
CK_ODT_240OHM   "CK_ODT_240OHM"
CK_UNTERM   "CK_UNTERM"
CK_ODT_60OHM_06VDDQ   "CK_ODT_60OHM, FOR 06VDDQ MODEL"
CK_ODT_120OHM_06VDDQ   "CK_ODT_120OHM, FOR 06VDDQ MODEL"
[Model Selector]   CS_PIN
CS_ODT_40OHM   "CS_ODT_40OHM"
CS_ODT_48OHM   "CS_ODT_48OHM"
CS_ODT_60OHM   "CS_ODT_60OHM"
CS_ODT_80OHM   "CS_ODT_80OHM"
CS_ODT_120OHM   "CS_ODT_120OHM"
CS_ODT_240OHM   "CS_ODT_240OHM"
CS_UNTERM   "CS_UNTERM"
CS_ODT_60OHM_06VDDQ   "CS_ODT_60OHM, FOR 06VDDQ MODEL"
CS_ODT_120OHM_06VDDQ   "CS_ODT_120OHM, FOR 06VDDQ MODEL"
[Model Selector]   DQ_PIN
DQ_40OHM_34OHM   "SOC_ODT=40ohm, PD=34ohm"
DQ_40OHM_40OHM   "SOC_ODT=40ohm, PD=40ohm"
DQ_40OHM_48OHM   "SOC_ODT=40ohm, PD=48ohm"
DQ_40OHM_60OHM   "SOC_ODT=40ohm, PD=60ohm"
DQ_48OHM_34OHM   "SOC_ODT=48ohm, PD=34ohm"
DQ_48OHM_40OHM   "SOC_ODT=48ohm, PD=40ohm"
DQ_48OHM_48OHM   "SOC_ODT=48ohm, PD=48ohm"
DQ_48OHM_60OHM   "SOC_ODT=48ohm, PD=60ohm"
DQ_60OHM_34OHM   "SOC_ODT=60ohm, PD=34ohm"
DQ_60OHM_40OHM   "SOC_ODT=60ohm, PD=40ohm"
DQ_60OHM_48OHM   "SOC_ODT=60ohm, PD=48ohm"
DQ_60OHM_60OHM   "SOC_ODT=60ohm, PD=60ohm"
DQ_80OHM_80OHM   "SOC_ODT=80ohm, PD=80ohm"
DQ_120OHM_120OHM   "SOC_ODT=120ohm, PD=120ohm"
DQ_240OHM_240OHM   "SOC_ODT=240ohm, PD=240ohm"
DQ_40OHM_34OHM_06VDDQ   "PU=40ohm, PD=34ohm, voh=0.6vddq"
DQ_40OHM_40OHM_06VDDQ   "PU=40ohm, PD=40ohm, voh=0.6vddq"
DQ_40OHM_48OHM_06VDDQ   "PU=40ohm, PD=48ohm, voh=0.6vddq"
DQ_40OHM_60OHM_06VDDQ   "PU=40ohm, PD=60ohm, voh=0.6vddq"
DQ_40OHM_80OHM_06VDDQ   "PU=40ohm, PD=80ohm, voh=0.6vddq"
DQ_40OHM_120OHM_06VDDQ  "PU=40ohm, PD=120ohm, voh=0.6vddq"
DQ_40OHM_240OHM_06VDDQ  "PU=40ohm, PD=240ohm, voh=0.6vddq"
DQ_80OHM_34OHM_06VDDQ   "PU=80ohm, PD=34ohm, voh=0.6vddq"
DQ_80OHM_40OHM_06VDDQ   "PU=80ohm, PD=40ohm, voh=0.6vddq"
DQ_80OHM_48OHM_06VDDQ   "PU=80ohm, PD=48ohm, voh=0.6vddq"
DQ_80OHM_60OHM_06VDDQ   "PU=80ohm, PD=60ohm, voh=0.6vddq"
DQ_80OHM_80OHM_06VDDQ   "PU=80ohm, PD=80ohm, voh=0.6vddq"
DQ_80OHM_120OHM_06VDDQ  "PU=80ohm, PD=120ohm, voh=0.6vddq"
DQ_80OHM_240OHM_06VDDQ  "PU=80ohm, PD=240ohm, voh=0.6vddq"
DQ_40OHM_34OHM_PREEMP_ON   "SOC_ODT=40ohm, PD=34ohm, preemp_on"
DQ_40OHM_40OHM_PREEMP_ON   "SOC_ODT=40ohm, PD=40ohm, preemp_on"
DQ_40OHM_48OHM_PREEMP_ON   "SOC_ODT=40ohm, PD=48ohm, preemp_on"
DQ_40OHM_60OHM_PREEMP_ON   "SOC_ODT=40ohm, PD=60ohm, preemp_on"
DQ_48OHM_34OHM_PREEMP_ON   "SOC_ODT=48ohm, PD=34ohm, preemp_on"
DQ_48OHM_40OHM_PREEMP_ON   "SOC_ODT=48ohm, PD=40ohm, preemp_on"
DQ_48OHM_48OHM_PREEMP_ON   "SOC_ODT=48ohm, PD=48ohm, preemp_on"
DQ_48OHM_60OHM_PREEMP_ON   "SOC_ODT=48ohm, PD=60ohm, preemp_on"
DQ_60OHM_34OHM_PREEMP_ON   "SOC_ODT=60ohm, PD=34ohm, preemp_on"
DQ_60OHM_40OHM_PREEMP_ON   "SOC_ODT=60ohm, PD=40ohm, preemp_on"
DQ_60OHM_48OHM_PREEMP_ON   "SOC_ODT=60ohm, PD=48ohm, preemp_on"
DQ_60OHM_60OHM_PREEMP_ON   "SOC_ODT=60ohm, PD=60ohm, preemp_on"
DQ_80OHM_80OHM_PREEMP_ON   "SOC_ODT=80ohm, PD=80ohm, preemp_on"
DQ_120OHM_120OHM_PREEMP_ON   "SOC_ODT=120ohm, PD=120ohm, preemp_on"
DQ_240OHM_240OHM_PREEMP_ON   "SOC_ODT=240ohm, PD=240ohm, preemp_on"
DQ_40OHM_34OHM_06VDDQ_PREEMP_ON "PU=40ohm, PD=34ohm, voh=0.6vddq, preemp_on"
DQ_40OHM_40OHM_06VDDQ_PREEMP_ON "PU=40ohm, PD=40ohm, voh=0.6vddq, preemp_on"
DQ_40OHM_48OHM_06VDDQ_PREEMP_ON "PU=40ohm, PD=48ohm, voh=0.6vddq, preemp_on"
DQ_40OHM_60OHM_06VDDQ_PREEMP_ON "PU=40ohm, PD=60ohm, voh=0.6vddq, preemp_on"
DQ_40OHM_80OHM_06VDDQ_PREEMP_ON "PU=40ohm, PD=80ohm, voh=0.6vddq, preemp_on"
DQ_40OHM_120OHM_06VDDQ_PREEMP_ON   "PU=40ohm, PD=120ohm, voh=0.6vddq, preemp_on"
DQ_40OHM_240OHM_06VDDQ_PREEMP_ON   "PU=40ohm, PD=240ohm, voh=0.6vddq, preemp_on"
DQ_80OHM_34OHM_06VDDQ_PREEMP_ON "PU=80ohm, PD=34ohm, voh=0.6vddq, preemp_on"
DQ_80OHM_40OHM_06VDDQ_PREEMP_ON "PU=80ohm, PD=40ohm, voh=0.6vddq, preemp_on"
DQ_80OHM_48OHM_06VDDQ_PREEMP_ON "PU=80ohm, PD=48ohm, voh=0.6vddq, preemp_on"
DQ_80OHM_60OHM_06VDDQ_PREEMP_ON "PU=80ohm, PD=60ohm, voh=0.6vddq, preemp_on"
DQ_80OHM_80OHM_06VDDQ_PREEMP_ON "PU=80ohm, PD=80ohm, voh=0.6vddq, preemp_on"
DQ_80OHM_120OHM_06VDDQ_PREEMP_ON   "PU=80ohm, PD=120ohm, voh=0.6vddq, preemp_on"
DQ_80OHM_240OHM_06VDDQ_PREEMP_ON   "PU=80ohm, PD=240ohm, voh=0.6vddq, preemp_on"
DQ_ODT_40OHM   "DQ_ODT_40OHM"
DQ_ODT_48OHM   "DQ_ODT_48OHM"
DQ_ODT_60OHM   "DQ_ODT_60OHM"
DQ_ODT_80OHM   "DQ_ODT_80OHM"
DQ_ODT_120OHM   "DQ_ODT_120OHM"
DQ_ODT_240OHM   "DQ_ODT_240OHM"
DQ_UNTERM   "DQ_UNTERM"
DQ_ODT_60OHM_06VDDQ   "DQ_ODT_60OHM, voh=0.6vddq"
DQ_ODT_120OHM_06VDDQ   "DQ_ODT_120OHM, voh=0.6vddq"
| Models and submodels in the file (67): CA_ODT_40OHM (Input), CA_ODT_48OHM (Input), CA_ODT_60OHM (Input), CA_ODT_80OHM (Input), CA_ODT_120OHM (Input), CA_ODT_240OHM (Input), CA_UNTERM (Input), CA_ODT_60OHM_06VDDQ (Input), CA_ODT_120OHM_06VDDQ (Input), CK_ODT_40OHM (Input), CK_ODT_48OHM (Input), CK_ODT_60OHM (Input), CK_ODT_80OHM (Input), CK_ODT_120OHM (Input), CK_ODT_240OHM (Input), CK_UNTERM (Input), CK_ODT_60OHM_06VDDQ (Input), CK_ODT_120OHM_06VDDQ (Input), CS_ODT_40OHM (Input), CS_ODT_48OHM (Input), CS_ODT_60OHM (Input), CS_ODT_80OHM (Input), CS_ODT_120OHM (Input), CS_ODT_240OHM (Input), CS_UNTERM (Input), CS_ODT_60OHM_06VDDQ (Input), CS_ODT_120OHM_06VDDQ (Input), DQ_40OHM_34OHM (I/O), DQ_40OHM_40OHM (I/O), DQ_40OHM_48OHM (I/O), DQ_40OHM_60OHM (I/O), DQ_48OHM_34OHM (I/O), DQ_48OHM_40OHM (I/O), DQ_48OHM_48OHM (I/O), DQ_48OHM_60OHM (I/O), DQ_60OHM_34OHM (I/O), DQ_60OHM_40OHM (I/O), DQ_60OHM_48OHM (I/O), DQ_60OHM_60OHM (I/O), DQ_80OHM_80OHM (I/O), DQ_120OHM_120OHM (I/O), DQ_240OHM_240OHM (I/O), DQ_40OHM_34OHM_06VDDQ (I/O), DQ_40OHM_40OHM_06VDDQ (I/O), DQ_40OHM_48OHM_06VDDQ (I/O), DQ_40OHM_60OHM_06VDDQ (I/O), DQ_40OHM_80OHM_06VDDQ (I/O), DQ_40OHM_120OHM_06VDDQ (I/O), DQ_40OHM_240OHM_06VDDQ (I/O), DQ_80OHM_34OHM_06VDDQ (I/O), DQ_80OHM_40OHM_06VDDQ (I/O), DQ_80OHM_48OHM_06VDDQ (I/O), DQ_80OHM_60OHM_06VDDQ (I/O), DQ_80OHM_80OHM_06VDDQ (I/O), DQ_80OHM_120OHM_06VDDQ (I/O), DQ_80OHM_240OHM_06VDDQ (I/O), DQ_40OHM_34OHM_PREEMP_ON (I/O), DQ_40OHM_40OHM_PREEMP_ON (I/O), DQ_40OHM_48OHM_PREEMP_ON (I/O), DQ_40OHM_60OHM_PREEMP_ON (I/O), DQ_48OHM_34OHM_PREEMP_ON (I/O), DQ_48OHM_40OHM_PREEMP_ON (I/O), DQ_48OHM_48OHM_PREEMP_ON (I/O), DQ_48OHM_60OHM_PREEMP_ON (I/O), DQ_60OHM_34OHM_PREEMP_ON (I/O), DQ_60OHM_40OHM_PREEMP_ON (I/O), DQ_60OHM_48OHM_PREEMP_ON (I/O)
